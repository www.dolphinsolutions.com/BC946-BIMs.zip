Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-03-19T08:51:34
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 19 08:51:34 2024 * Host: Yogoon * Database: C:\Users\gokul\AppData\Local\Temp\2e13ad9b-9c38-4c71-93a6-3bb9e012d381\c7daf936-5e69-4d76-b99b-b5ec670140cc\ifc * Database version: 5507 * Database creation date: Tue Mar 19 08:51:33 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Mar 19 08:51:34 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 19 08:51:34 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: BC946, BC946:BC946:348667
In: Level 1
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 122 mm; Height: 320 mm; Width: 320 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_70_22_90 Toilet paper dispensers; CAWS: N13/462 Toilet paper holders; CodePerformance: n/a; Color: Brushed Satin-BC946 or Polished-BC946B; Constituents: n/a; Description: Jumbo Toilet Tissue Dispenser; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Brushed Satin-BC946 or Polished-BC946B; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: www.dolphinsolutions.co.uk; Material: StainlessSteel; ModelNumber: BC946/BC946B; ModelReference: DolphinSolutionsLimited_JumboToiletTissueDispenser; Name: JumboToiletTissueDispenser_DolphinSolutionsLimited; NBSDescription: Toilet paper dispensers; NBSTypeID: n/a; NominalDepth: 122; NominalHeight: 320; NominalLength: 320; ObjectClassification: 23.40.20.21.21; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-jumbo-roll-toilet-tissue-dispenser/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: Round; Size: 320 x 320 x 122 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC946; Uniclass2015Code: Pr_40_70_22_90; Uniclass2015Title: Toilet paper dispensers; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Generic Models; Family Name: BC946
Type - Pset_BuildingElementProxyCommon - Reference: BC946:BC946
Type - Pset_ElementShading - Color: Brushed Satin-BC946 or Polished-BC946B
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_JumboToiletTissueDispenser; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_PrecastConcreteElementGeneral - SerialNumber: n/a
Type - Pset_ProductRequirements - Name: JumboToiletTissueDispenser_DolphinSolutionsLimited; Category: Pr_40_70_22_90 Toilet paper dispensers
Type - Pset_QuantityTakeOff - Reference: BC946:BC946
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProductRequirements - Category: Generic Models
Constraints - Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.185639 m2; Volume: 0.00760758 m3
Other - Family: BC946: BC946; Family and Type: BC946: BC946; Type: BC946: BC946; Type Id: BC946: BC946
Phasing - Phase Created: New Construction
